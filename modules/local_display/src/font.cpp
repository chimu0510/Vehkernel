// The local display's font (ADR-0022): ASCII 0x20 to 0x7E, 5 x 7 pixels in a
// 6 x 8 cell, drawn for Vehkernel. Each glyph is written as seven rows, top
// first, '#' lit; glyph_columns() turns them into columns at compile time.
#include <vk/local_display/font.hpp>

#include <array>
#include <cstddef>
#include <cstdint>
#include <string_view>

namespace vk::local_display {

namespace {

using Rows = std::array<std::string_view, font_height>;

// clang-format off
constexpr std::array<Rows, glyph_count> glyph_rows{{
    {".....", ".....", ".....", ".....", ".....", ".....", "....."},  // space
    {"..#..", "..#..", "..#..", "..#..", "..#..", ".....", "..#.."},  // !
    {".#.#.", ".#.#.", ".#.#.", ".....", ".....", ".....", "....."},  // quotation mark
    {".#.#.", ".#.#.", "#####", ".#.#.", "#####", ".#.#.", ".#.#."},  // #
    {"..#..", ".####", "#.#..", ".###.", "..#.#", "####.", "..#.."},  // $
    {"##...", "##..#", "...#.", "..#..", ".#...", "#..##", "...##"},  // %
    {".##..", "#..#.", "#.#..", ".#...", "#.#.#", "#..#.", ".##.#"},  // &
    {"..#..", "..#..", ".#...", ".....", ".....", ".....", "....."},  // apostrophe
    {"...#.", "..#..", ".#...", ".#...", ".#...", "..#..", "...#."},  // (
    {".#...", "..#..", "...#.", "...#.", "...#.", "..#..", ".#..."},  // )
    {".....", "..#..", "#.#.#", ".###.", "#.#.#", "..#..", "....."},  // *
    {".....", "..#..", "..#..", "#####", "..#..", "..#..", "....."},  // +
    {".....", ".....", ".....", ".....", ".##..", "..#..", ".#..."},  // ,
    {".....", ".....", ".....", "#####", ".....", ".....", "....."},  // -
    {".....", ".....", ".....", ".....", ".....", ".##..", ".##.."},  // .
    {".....", "....#", "...#.", "..#..", ".#...", "#....", "....."},  // /
    {".###.", "#...#", "#..##", "#.#.#", "##..#", "#...#", ".###."},  // 0
    {"..#..", ".##..", "..#..", "..#..", "..#..", "..#..", ".###."},  // 1
    {".###.", "#...#", "....#", "...#.", "..#..", ".#...", "#####"},  // 2
    {"#####", "...#.", "..#..", "...#.", "....#", "#...#", ".###."},  // 3
    {"...#.", "..##.", ".#.#.", "#..#.", "#####", "...#.", "...#."},  // 4
    {"#####", "#....", "####.", "....#", "....#", "#...#", ".###."},  // 5
    {"..##.", ".#...", "#....", "####.", "#...#", "#...#", ".###."},  // 6
    {"#####", "....#", "...#.", "..#..", ".#...", ".#...", ".#..."},  // 7
    {".###.", "#...#", "#...#", ".###.", "#...#", "#...#", ".###."},  // 8
    {".###.", "#...#", "#...#", ".####", "....#", "...#.", ".##.."},  // 9
    {".....", ".##..", ".##..", ".....", ".##..", ".##..", "....."},  // :
    {".....", ".##..", ".##..", ".....", ".##..", "..#..", ".#..."},  // ;
    {"...#.", "..#..", ".#...", "#....", ".#...", "..#..", "...#."},  // <
    {".....", ".....", "#####", ".....", "#####", ".....", "....."},  // =
    {".#...", "..#..", "...#.", "....#", "...#.", "..#..", ".#..."},  // >
    {".###.", "#...#", "....#", "...#.", "..#..", ".....", "..#.."},  // ?
    {".###.", "#...#", "....#", ".##.#", "#.#.#", "#.#.#", ".###."},  // @
    {".###.", "#...#", "#...#", "#####", "#...#", "#...#", "#...#"},  // A
    {"####.", "#...#", "#...#", "####.", "#...#", "#...#", "####."},  // B
    {".###.", "#...#", "#....", "#....", "#....", "#...#", ".###."},  // C
    {"###..", "#..#.", "#...#", "#...#", "#...#", "#..#.", "###.."},  // D
    {"#####", "#....", "#....", "####.", "#....", "#....", "#####"},  // E
    {"#####", "#....", "#....", "####.", "#....", "#....", "#...."},  // F
    {".###.", "#...#", "#....", "#.###", "#...#", "#...#", ".####"},  // G
    {"#...#", "#...#", "#...#", "#####", "#...#", "#...#", "#...#"},  // H
    {".###.", "..#..", "..#..", "..#..", "..#..", "..#..", ".###."},  // I
    {"..###", "...#.", "...#.", "...#.", "...#.", "#..#.", ".##.."},  // J
    {"#...#", "#..#.", "#.#..", "##...", "#.#..", "#..#.", "#...#"},  // K
    {"#....", "#....", "#....", "#....", "#....", "#....", "#####"},  // L
    {"#...#", "##.##", "#.#.#", "#.#.#", "#...#", "#...#", "#...#"},  // M
    {"#...#", "#...#", "##..#", "#.#.#", "#..##", "#...#", "#...#"},  // N
    {".###.", "#...#", "#...#", "#...#", "#...#", "#...#", ".###."},  // O
    {"####.", "#...#", "#...#", "####.", "#....", "#....", "#...."},  // P
    {".###.", "#...#", "#...#", "#...#", "#.#.#", "#..#.", ".##.#"},  // Q
    {"####.", "#...#", "#...#", "####.", "#.#..", "#..#.", "#...#"},  // R
    {".####", "#....", "#....", ".###.", "....#", "....#", "####."},  // S
    {"#####", "..#..", "..#..", "..#..", "..#..", "..#..", "..#.."},  // T
    {"#...#", "#...#", "#...#", "#...#", "#...#", "#...#", ".###."},  // U
    {"#...#", "#...#", "#...#", "#...#", "#...#", ".#.#.", "..#.."},  // V
    {"#...#", "#...#", "#...#", "#.#.#", "#.#.#", "#.#.#", ".#.#."},  // W
    {"#...#", "#...#", ".#.#.", "..#..", ".#.#.", "#...#", "#...#"},  // X
    {"#...#", "#...#", ".#.#.", "..#..", "..#..", "..#..", "..#.."},  // Y
    {"#####", "....#", "...#.", "..#..", ".#...", "#....", "#####"},  // Z
    {".###.", ".#...", ".#...", ".#...", ".#...", ".#...", ".###."},  // [
    {".....", "#....", ".#...", "..#..", "...#.", "....#", "....."},  // backslash
    {".###.", "...#.", "...#.", "...#.", "...#.", "...#.", ".###."},  // ]
    {"..#..", ".#.#.", "#...#", ".....", ".....", ".....", "....."},  // ^
    {".....", ".....", ".....", ".....", ".....", ".....", "#####"},  // _
    {".#...", "..#..", "...#.", ".....", ".....", ".....", "....."},  // `
    {".....", ".....", ".###.", "....#", ".####", "#...#", ".####"},  // a
    {"#....", "#....", "#.##.", "##..#", "#...#", "#...#", "####."},  // b
    {".....", ".....", ".###.", "#....", "#....", "#...#", ".###."},  // c
    {"....#", "....#", ".##.#", "#..##", "#...#", "#...#", ".####"},  // d
    {".....", ".....", ".###.", "#...#", "#####", "#....", ".###."},  // e
    {"..##.", ".#..#", ".#...", "###..", ".#...", ".#...", ".#..."},  // f
    {".....", ".####", "#...#", "#...#", ".####", "....#", ".###."},  // g
    {"#....", "#....", "#.##.", "##..#", "#...#", "#...#", "#...#"},  // h
    {"..#..", ".....", ".##..", "..#..", "..#..", "..#..", ".###."},  // i
    {"...#.", ".....", "..##.", "...#.", "...#.", "#..#.", ".##.."},  // j
    {"#....", "#....", "#..#.", "#.#..", "##...", "#.#..", "#..#."},  // k
    {".##..", "..#..", "..#..", "..#..", "..#..", "..#..", ".###."},  // l
    {".....", ".....", "##.#.", "#.#.#", "#.#.#", "#...#", "#...#"},  // m
    {".....", ".....", "#.##.", "##..#", "#...#", "#...#", "#...#"},  // n
    {".....", ".....", ".###.", "#...#", "#...#", "#...#", ".###."},  // o
    {".....", ".....", "####.", "#...#", "####.", "#....", "#...."},  // p
    {".....", ".....", ".##.#", "#..##", ".####", "....#", "....#"},  // q
    {".....", ".....", "#.##.", "##..#", "#....", "#....", "#...."},  // r
    {".....", ".....", ".###.", "#....", ".###.", "....#", "####."},  // s
    {".#...", ".#...", "###..", ".#...", ".#...", ".#..#", "..##."},  // t
    {".....", ".....", "#...#", "#...#", "#...#", "#..##", ".##.#"},  // u
    {".....", ".....", "#...#", "#...#", "#...#", ".#.#.", "..#.."},  // v
    {".....", ".....", "#...#", "#...#", "#.#.#", "#.#.#", ".#.#."},  // w
    {".....", ".....", "#...#", ".#.#.", "..#..", ".#.#.", "#...#"},  // x
    {".....", ".....", "#...#", "#...#", ".####", "....#", ".###."},  // y
    {".....", ".....", "#####", "...#.", "..#..", ".#...", "#####"},  // z
    {"...#.", "..#..", "..#..", ".#...", "..#..", "..#..", "...#."},  // {
    {"..#..", "..#..", "..#..", "..#..", "..#..", "..#..", "..#.."},  // |
    {".#...", "..#..", "..#..", "...#.", "..#..", "..#..", ".#..."},  // }
    {".....", ".....", ".#...", "#.#.#", "...#.", ".....", "....."},  // ~
}};
// clang-format on

constexpr std::array<Glyph, glyph_count> glyph_columns()
{
    std::array<Glyph, glyph_count> glyphs{};
    for (std::size_t g = 0; g < glyph_count; ++g) {
        for (std::size_t row = 0; row < font_height; ++row) {
            for (std::size_t column = 0; column < font_width; ++column) {
                if (glyph_rows.at(g).at(row).at(column) == '#') {
                    glyphs.at(g).at(column) = static_cast<std::uint8_t>(glyphs.at(g).at(column) | (1U << row));
                }
            }
        }
    }
    return glyphs;
}

constexpr std::array<Glyph, glyph_count> glyphs = glyph_columns();

static_assert(glyphs.at('A' - first_glyph).at(0) == 0x7E, "the first column of A is lit from row 1 to row 6");

}  // namespace

const Glyph& glyph(char c)
{
    const auto code = static_cast<unsigned char>(c);
    if (code < first_glyph || code >= first_glyph + glyph_count) {
        return glyphs.at('?' - first_glyph);
    }
    return glyphs.at(code - first_glyph);
}

}  // namespace vk::local_display
